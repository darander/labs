FILESEXTRAPATHS_prepend_lab-qemuarm := "${THISDIR}/${PN}:"

PRINC = "1"
