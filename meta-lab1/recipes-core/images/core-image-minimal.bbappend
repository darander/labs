IMAGE_INSTALL_append = " \
    ncurses-libncurses \
    ncurses-libtinfo \
    ncurses-terminfo-base \
"

