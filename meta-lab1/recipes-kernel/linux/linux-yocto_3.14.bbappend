
KERNEL_IMAGETYPE_beaglebone = "zImage"
